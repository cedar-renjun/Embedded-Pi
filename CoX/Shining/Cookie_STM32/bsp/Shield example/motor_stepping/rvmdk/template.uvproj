# Keil uVision project template.uvproj, settings and files
target Debug_Flash (ARM-ADS)
  device: M0516LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: template
  c flags: Optim=1
  c define: rvmdk
  c include: ..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_M051\libcox;..\..\..\..\libshining;..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_M051\startup\src;..\..\..\..\..\Shield\Adafruit_Industries\Motor_Shield
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry ResetHandler
  group rvmdk
    ../../../../../CoX_Peripheral/CoX_Peripheral_M051/startup/src/: startup_rvmdk.s
  group libcox_inc
    ../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xsysctl.h xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_pwm.h xhw_sysctl.h xhw_types.h xpwm.h xtimer.h xhw_timer.h
  group libcox_src
    ../../../../../CoX_Peripheral/CoX_Peripheral_M051/libcox/: xpwm.c xsysctl.c xcore.c xdebug.c xgpio.c xtimer.c
  group Co-Shining
    ../../../../libshining/: coshining.h coshining_cfg.h
  group Source
    ../: main.c
  group MotorShield
    ../../../../../Shield/Adafruit_Industries/Motor_Shield/: MotorShield.c MotorShield.h
target Debug_Ram (ARM-ADS)
  device: NUC140LD3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: template
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\..\..\CoX_Peripheral\CoX_Peripheral_M051\libcox;..\..\..\..\libshining
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
  scatter file: .\m051_ram.sct
  link misc: --entry ResetHandler
