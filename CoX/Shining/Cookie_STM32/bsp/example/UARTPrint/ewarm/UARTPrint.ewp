# IAR project UARTPrint.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\..\..\libCookie; ..\..\..\..\..\..\Cox_Peripheral\Cox_Peripheral_STM32F1xx\libcox
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: UARTPrint.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../: main.c
    ../src/: UARTPrint.c
  group Config
    ../../../../libCookie/: cookie.h cookie_cfg.h
  group CoxLib/inc
    ../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xacmp.h xadc.h xcore.h xdebug.h xdma.h xgpio.h xhw_adc.h xhw_config.h xhw_dma.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_rtc.h xhw_spi.h xhw_sysctl.h xhw_timer.h xhw_types.h xhw_uart.h xhw_wdt.h xi2c.h xpwm.h xrtc.h xspi.h xsysctl.h xtimer.h xuart.h xwdt.h
  group CoxLib/src
    ../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/libcox/: xadc.c xcore.c xdebug.c xdma.c xgpio.c xi2c.c xpwm.c xrtc.c xspi.c xsysctl.c xtimer.c xuart.c xwdt.c
  group Startup
    ../../../../../../CoX_Peripheral/CoX_Peripheral_STM32F1xx/startup/src/: startup_ewarm.s
